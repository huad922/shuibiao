# Keil uVision project IR.uvproj, settings and files
target Target 1 (MCS-251)
  device: Flip80251 Hurricane Dolphin
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: IR +hex
  group Source Group 1
    ./: START251.A51
    ./SRC/: main.c sys.h AD.c AD.h Flash.c Flash.h Uart.c Uart.h RTC.c RTC.h HT1621.c HT1621.h Calculate.c Calculate.h LCD.c LCD.h
